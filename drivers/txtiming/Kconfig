## drivers/txtiming/Kconfig
```kconfig
config TXTIMING
	tristate "TxTiming Module"
	depends on ARM
	default y if ARM
	help
		TxTiming Module
```
